# Keil uVision project FUTBA-13ST84GINK.uvprojx, settings and files
target FUTABA-13ST84GINK (ARM-ADS)
  device: STM32F030C8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: FUTABA_VFD_13ST84GINK +hex
  c flags: Optim=4
  c define: USE_STDPERIPH_DRIVER STM32F0XX
  c include: ..\CORE;..\HARDWARE;..\STM32F03x_FWLib\inc;..\STM32F03x_FWLib\src;..\SYSTEM;..\SOFTWARE;..\HARDWARE\MCU_HARDWARE;..\HARDWARE\FUTABA_13ST84GINK;..\HARDWARE\LED
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group SOFTWARE
    ../SOFTWARE/: Main.c Runtime.c
  group CORE
    ../CORE/: startup_stm32f0xx.s
  group HARDWARE
    ../HARDWARE/MCU_HARDWARE/: STF030_Interrupt.c STF030_Timer.c STF030_Rcc.c STF030_Gpio.c
    ../HARDWARE/LED/: LED.c
    ../HARDWARE/FUTABA_13ST84GINK/: FUTABA_VFD.c
  group SYSTEM
    ../SYSTEM/: system_stm32f0xx.c delay.c
  group STM32F03x_FWLib
    ../STM32F03x_FWLib/src/: stm32f0xx_gpio.c stm32f0xx_rcc.c stm32f0xx_misc.c stm32f0xx_usart.c stm32f0xx_syscfg.c stm32f0xx_tim.c
